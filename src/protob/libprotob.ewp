# IAR project libprotob.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: SDK_VERSION="4.0.23"; _NO_DEFINITIONS_IN_HEADER_FILES; TARGET_OS_LINUX=1; LINUX32=1; __KINOMA_IPP__=1; KINOMA_MP3=1; KINOMA_FAST_HUFFMAN=1; _GNU_SOURCE; mxRun=1; mxMC=1; XS_ARCHIVE=1; _DEBUG=1; mxDebug=1; mxReport=0; mxStress=1; mxProfile=0; BUILT_4_MC=1; __SSLIBC__=1; MBEDTLS_CONFIG_FILE=<default.h>; HAVE_EXPAT_CONFIG_H; _ENABLE_THREAD_SUPPORT_
  ICCARM.PreInclude: $WS_DIR$\bin\mw300_defconfig\autoconf.h
  ICCARM.CCIncludePath2: $WS_DIR$\.; $WS_DIR$\sdk\src\incl\sdk; $WS_DIR$\sdk\src\incl\sdk\crypto; $WS_DIR$\sdk\src\incl\sdk\drivers; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300; $WS_DIR$\sdk\src\incl\sdk\drivers\mw300\regs; $WS_DIR$\sdk\src\incl\sdk\drivers\wlan; $WS_DIR$\sdk\src\incl\sdk\drivers\bt; $WS_DIR$\sdk\src\incl\libc\iar; $WS_DIR$\sdk\src\boards; $WS_DIR$\sdk\src\incl\ble\include; $WS_DIR$\sdk\src\incl\ble\fp0; $WS_DIR$\sdk\src\middleware\audio\mp3_decoder\inc; $WS_DIR$\sdk\src\incl\platform\os\freertos; $WS_DIR$\sdk\external\freertos\Source\include\; $WS_DIR$\sdk\external\freertos\; $WS_DIR$\sdk\external\freertos\Source\portable\IAR\ARM_CM4F; $WS_DIR$\sdk\src\incl\platform\net\lwip; $WS_DIR$\sdk\external\lwip\src\include\; $WS_DIR$\sdk\external\lwip\src\include\ipv4; $WS_DIR$\sdk\external\lwip\src\include\ipv6; $WS_DIR$\sdk\external\lwip\contrib\port\FreeRTOS\wmsdk\; $WS_DIR$\sdk\external\mbedtls\upstream\include; $WS_DIR$\sdk\external\mbedtls\port; $WS_DIR$\sdk\external\mbedtls\helper_api; $WS_DIR$\sdk\external\mbedtls\config; $WS_DIR$\sdk\external\expat-2.1.0\lib; $WS_DIR$\sdk\external\expat-2.1.0; $WS_DIR$\sdk\external\nghttp2\lib\includes; $WS_DIR$\sdk\external\usb-host\incl; $WS_DIR$\sdk\external\aws_iot\include; $WS_DIR$\sdk\src\incl\libc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libjson_parser.a
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; SDK_VERSION="4.0.23"; _NO_DEFINITIONS_IN_HEADER_FILES; TARGET_OS_LINUX=1; LINUX32=1; __KINOMA_IPP__=1; KINOMA_MP3=1; KINOMA_FAST_HUFFMAN=1; _GNU_SOURCE; mxRun=1; mxMC=1; XS_ARCHIVE=1; _DEBUG=1; mxDebug=1; mxReport=0; mxStress=1; mxProfile=0; BUILT_4_MC=1; __SSLIBC__=1; MBEDTLS_CONFIG_FILE=<default.h>; HAVE_EXPAT_CONFIG_H; _ENABLE_THREAD_SUPPORT_
  ICCARM.CCOptStrategy: 0
  group (top)
    $WS_DIR$/sdk/src/middleware/protob/: pb_common.c pb_decode.c MsgUtil.c ConnectReq.pb.c DisconnectReq.pb.c ConnectResp.pb.c
    $WS_DIR$/sdk/src/middleware/protob/pb_encode.c$WS_DIR$/sdk/src/middleware/protob/: simple.pb.c
    /
$WS_DIR$/sdk/src/middleware/protob/: DisconnectResp.pb.c AlterMasterPush.pb.c HwAddCustomVoicePush.pb.c HwAddDiscussPush.pb.c HwCacheVoicePush.pb.c HwCapacityPush.pb.c HwCapacityToAppReq.pb.c HwChangeListOrderPush.pb.c HwChangeNamePush.pb.c HwChangeStatusReq.pb.c HwClosePush.pb.c HwDeleteCustomVoicePush.pb.c HwDeleteDownloadedVoicePush.pb.c HwDeleteGroupVoicePush.pb.c HwDeleteSDVoicePush.pb.c HwDeleteVoicePush.pb.c HwDLLocalPush.pb.c HwDLLocalStatusReq.pb.c HwDLLocalToAppReq.pb.c HwGetWifiPush.pb.c HwOperateStatusReq.pb.c HwPlayControlPush.pb.c HwPlayModePush.pb.c HwPlayPush.pb.c HwPowerStatusReq.pb.c HwPullDiscussReq.pb.c HwPullVoiceListReq.pb.c HwPullVoiceReq.pb.c HwRegisterReq.pb.c HwRegisterResp.pb.c HwReleaseVoicePush.pb.c HwReleaseVoiceReq.pb.c HwSdVoiceAddReq.pb.c
